# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group Source Group 1
    ./Code/: GPIO.C
  group Common
    ./Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
  group include
    ./Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
